Commit message: update

File: examples/Darias/scenario_description/region.urdf (robot description, URDF)
Before this commit: robot region, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.2001 0.2001 0.005; visual box size=0.2001 0.2001 0.00005
